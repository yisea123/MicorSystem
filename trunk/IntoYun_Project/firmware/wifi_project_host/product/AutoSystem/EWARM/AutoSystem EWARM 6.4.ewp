# IAR project AutoSystem EWARM 6.4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa093,Pa082
  ICCARM.CCIncludePath2: ..\Application\product\inc\; ..\Application\user\inc; ..\Application\apps; ..\Application\interface; ..\..\..\Middlewares\handler; ..\..\..\Middlewares\interface; ..\..\..\Middlewares\log; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\comm; ..\..\..\Hal; ..\..\..\Hal\platform; ..\..\..\Hal\Components\oled; ..\..\..\Hal\Components\sht2x; ..\..\..\Hal\Components\inclination; ..\..\..\Hal\Components\presence; ..\..\..\Hal\Components\light; ..\..\..\Hal\Components\jdq; ..\..\..\Hal\Components\motor; ..\..\..\Hal\Components\spiFlash; ..\..\..\Lib\intoyun\inc; ..\..\..\Lib\Utils\; ..\..\..\Lib\Devices\; ..\..\..\Lib\STM32_DEV\; ..\..\..\Lib\Libraries\CMSIS\Core\CM3\; ..\..\..\Lib\Libraries\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Application\user\inc
  OBJCOPY.OOCOutputFile: wifi_project_host EWARM 6.4.hex
  ILINK.IlinkOutputFile: wifi_project_host EWARM 6.4.out
  ILINK.IlinkIcfFile: ..\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: AutoHouse EWARM 6.4.out
  group application/main
    ../Application/user/src/: freertos.c Init.c main.c State.c stm32f10x_it.c
  group application/product
    ../Application/product/src/: user_Action.c user_Handler.c user_IntoYun.c
  group hal/board
    ../../../Hal/: board.c
  group hal/Components/inclination
    ../../../Hal/Components/inclination/: inclination.c
  group hal/Components/jdq
    ../../../Hal/Components/jdq/: jdq.c
  group hal/Components/light
    ../../../Hal/Components/light/: light.c
  group hal/Components/motor
    ../../../Hal/Components/motor/: motor.c motor_handler.c
  group hal/Components/oled
    ../../../Hal/Components/oled/: oled.c
  group hal/Components/presence
    ../../../Hal/Components/presence/: presence.c
  group hal/Components/sht2x
    ../../../Hal/Components/sht2x/: sht2x.c
  group hal/Components/spiFlash
    ../../../Hal/Components/spiFlash/: WQ25XX.c
  group hal/ewarm
    ../: stm32f10x_flash.icf
  group hal/intoyun
    ../../../Lib/intoyun/src/: intoyun_datapoint.c intoyun_hal.c intoyun_interface.c intoyun_key.c intoyun_log.c intoyun_md5.c intoyun_protocol.c intoyun_timer.c
  group hal/libraries/CMSIS
    ../../../Lib/Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
    ../../../Lib/Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
  group hal/libraries/STM32F10x_StdPeriph_Driver
    ../../../Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal/platform
    ../../../Hal/platform/: platform_def.h
  group hal/stm32_drv
    ../../../Lib/STM32_DEV/: ADC.c I2C.c IAP.c RTC.c SPIx.c Stm32hal.c Timer.c USART.c WDG.c
  group hal/stm32_drv/gpio
    ../../../Lib/STM32_DEV/gpio/: gpio.c
  group hal/utils
    ../../../Lib/Utils/: TM_util.c Util.c
  group Middlewares/comm
    ../../../Middlewares/comm/: mcs_protocol.c
  group Middlewares/handler
    ../../../Middlewares/handler/: apps_commHandler.c apps_InforSave.c
  group Middlewares/interface
    ../../../Middlewares/interface/: Interface_bootloader.c Interface_dev.c Interface_inclin.c Interface_jdq.c Interface_kitchen.c Interface_light.c interface_monitor.c Interface_presence.c Interface_tv.c
  group Middlewares/log
    ../../../Middlewares/log/: log.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
