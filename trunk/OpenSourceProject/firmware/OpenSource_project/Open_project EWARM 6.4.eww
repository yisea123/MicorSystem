<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Open_project EWARM 6.4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


