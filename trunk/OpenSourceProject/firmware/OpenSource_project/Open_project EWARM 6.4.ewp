# IAR project Open_project EWARM 6.4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCDiagSuppress: Pe223,Pa093,Pa050,Pa082
  ICCARM.CCIncludePath2: Application\user; Application\apps; AppMain\; midlayer\protocol\; Lib\board\; Lib\intoyun\inc; Lib\Utils\; Lib\devices\; Lib\STM32_DEV\; Lib\Libraries\CMSIS\Core\CM3\; Lib\Libraries\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Open_project EWARM 6.4.hex
  ILINK.IlinkOutputFile: OpenSource.out
  ILINK.IlinkIcfFile: EWARM\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group hal/board
    Lib/board/: board.c
  group hal/devices
    Lib/devices/: sht2x.c WQ25XX.c
  group hal/ewarm
    EWARM/: stm32f10x_flash.icf
  group hal/intoyun
    Lib/intoyun/src/: intoyun_datapoint.c intoyun_hal.c intoyun_interface.c intoyun_key.c intoyun_log.c intoyun_md5.c intoyun_protocol.c intoyun_timer.c
  group hal/libraries/CMSIS
    Lib/Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
    Lib/Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
  group hal/libraries/STM32F10x_StdPeriph_Driver
    Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal/stm32_drv
    Lib/STM32_DEV/: ADC.c i2c.c RTC.c SPIx.c Stm32hal.c Timer.c USART.c WDG.c
  group hal/utils
    Lib/Utils/: TM_util.c Util.c
  group midlayer/protocol
    midlayer/protocol/: mcs_protocol.c
  group product/apps
    application/apps/: apps_commHandler.c apps_download.c apps_UploadSht20.c
  group product/user
    application/user/: Init.c main.c state.c stm32f10x_it.c user_Intoyun.c
