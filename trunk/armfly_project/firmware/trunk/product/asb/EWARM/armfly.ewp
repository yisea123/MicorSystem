# IAR project armfly.ewp, settings and files
configuration armfly (ARM, debug)
  General.OGChipSelectEditMenu: STM32F415RG ST STM32F415RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; HAL_STM32F4; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: ../Application/Inc; ../../../util/console; ../../../systemInc/; ../../../hal/sensor/veml6030; ../../../hal/sensor/hts221; ../../../hal/stm32f4lib/inc; ../../../hal/components/spiflash; ../../../hal/components/spiflash/IS25LPXX; ../../../hal/board/; ../../../hal/board/asb/inc; ../../../hal/board/asb/src; ../../../hal/usart/inc; ../../../hal/usart/stm32f4; ../../../hal/spi/; ../../../hal/i2c/stm32f4; ../../../hal/spi/stm32f4; ../../../hal/hal/stm32f4; ../../../hal/gpio/; ../../../hal/gpio/inc; ../../../hal/gpio/stm32f4; ../../../hal/stm32f4lib/Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../hal/stm32f4lib/Drivers/STM32F4xx_HAL_Driver/Inc; ../../../hal/stm32f4lib/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Application\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: armfly.out
  ILINK.IlinkIcfFile: E:\MicorSystem\trunk\asb\firmware\Asb_Board\Asb\EWARM\stm32f415xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Application/Src/: freertos.c main.c
  group hal/board
    ../../../hal/board/: board.c
  group hal/board/asb
    ../../../hal/board/asb/src/: boarddiv.c
  group hal/components/spiflash
    ../../../hal/components/spiflash/: spiflash.c
  group hal/sensors/hts221
    ../../../hal/sensor/hts221/: hts221.c
  group hal/sensors/veml6030
    ../../../hal/sensor/veml6030/: veml6030.c
  group hal/stm32/gpio
    ../../../hal/gpio/src/: gpio.c
  group hal/stm32/hal
    ../../../hal/hal/stm32f4/: hal.c
  group hal/stm32/i2c
    ../../../hal/i2c/stm32f4/: i2c.c
  group hal/stm32/spi
    ../../../hal/spi/stm32f4/: spi.c
  group hal/stm32/stm32f4lib
    ../../../hal/stm32f4lib/inc/: startup_stm32f407xx.s
    ../../../hal/stm32f4lib/src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
  group hal/stm32/stm32f4lib/Drivers/CMSIS
    ../../../hal/stm32f4lib/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group hal/stm32/stm32f4lib/Drivers/STM32F4xx_HAL_Driver
    ../../../hal/stm32f4lib/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_dma.c
  group hal/stm32/usart
    ../../../hal/usart/stm32f4/: usart.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group systemInc
    ../../../systemInc/: platform_assert.c
  group util/console
    ../../../util/console/: console.c
