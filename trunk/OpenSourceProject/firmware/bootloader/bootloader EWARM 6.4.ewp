# IAR project bootloader EWARM 6.4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCDiagSuppress: Pe188
  ICCARM.CCIncludePath2: Application\user; Application\apps; AppMain\; midlayer\protocol\; Lib\board\; Lib\intoyun\inc; Lib\Utils\; Lib\Devices\; Lib\STM32_DEV\; Lib\Libraries\CMSIS\Core\CM3\; Lib\Libraries\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootleader.hex
  ILINK.IlinkOutputFile: bootleader.out
  ILINK.IlinkIcfFile: EWARM\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group hal/board
    Lib/board/: board.c WQ25XX.c
  group hal/ewarm
    EWARM/: stm32f10x_flash.icf
  group hal/libraries/CMSIS
    Lib/Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
    Lib/Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
  group hal/libraries/STM32F10x_StdPeriph_Driver
    Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal/stm32_drv
    Lib/STM32_DEV/: ADC.c IAP.c RTC.c SPIx.c Stm32hal.c Timer.c USART.c WDG.c
  group hal/utils
    Lib/Utils/: TM_util.c Util.c
  group product/user
    application/user/: fw_upload.c Init.c main.c state.c stm32f10x_it.c
